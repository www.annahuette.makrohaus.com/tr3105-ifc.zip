Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnr.
Time: 2021-03-16T10:40:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.20.44 - Exporter 21.1.20.44 - Alternativ-UI 21.1.20.44
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 16 10:40:00 2021 * Host: NFR0046 * Database: C:\Users\A_GALL~1\AppData\Local\Temp\4bf9be7f-0f16-4d7c-9241-a983e0998028\a621cd8e-2d2c-409e-abd9-0c4b97e0eef1\ifc * Database version: 5507 * Database creation date: Tue Mar 16 10:39:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 16 10:40:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 16 10:40:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnr.
LongName: Bauvorhaben; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 48, 7, 58, 799999; RefLongitude: 11, 34, 58, 799999; RefElevation: 0 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de

# IfcBuilding
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene OKD, Ebene 0
LongName: Ebene 0; Elevation: 5.21586e-13 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene OKD
Grafiken(Type) - Farbe: 16711680; Linienmuster: _Strichpunkt - Mittel; Linienstärke: 1; Symbol: Beschriftung Ebene: Oberkante; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Text - SOFiSTiK_Level: 00
Sonstige - Familie: Ebene: Ebene OKD; Familie und Typ: Ebene: Ebene OKD; Kategorie: Ebenen; Typ: Ebene: Ebene OKD; Typ-ID: Ebene: Ebene OKD
Pset_AirSideSystemInformation - Name: Ebene 0; sets with these values: 2
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no

# IfcMechanicalFastener: TR3105:TR 3105-ø22, TR3105:TR 3105-ø22:1968212: 0
In: Ebene 0
NominalDiameter: 0.150919 m; NominalLength: 0.62336 m
Pset_BuildingElementProxyCommon - Reference: TR3105:TR 3105-ø22; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Konstruktion - Verbindungsmittelnummer: 1
Phasen - Phase erstellt: Phase 1
Satz - Menge: 1
Sonstige - Familie: TR3105: TR 3105-ø22; Familie und Typ: TR3105: TR 3105-ø22; Kategorie: Verbindungsmittel; Typ: TR3105: TR 3105-ø22; Typ-ID: TR3105: TR 3105-ø22

# IfcBuildingElementProxyType, no part of this type: TR3105:TR 3105-ø22
Abmessungen - Außendurchmesser: 0.046 m; Einfassung Stab 1: 0.055 m; Einfassung Stab 2: 0.065 m; Gesamtlänge: 0.19 m; TR3013-L0: 0.015 m; TR3013-Lm: 0.05 m; TR3013-Lw: 0.065 m; TR3013-ød: 0.025 m; TR3013-SW: 0.046 m; TR3014-L: 0.16 m; TR3014-L1: 0.055 m; TR3014-L2: 0.05 m; TR3014-SW: 0.046 m; TR3105-minA: 0.035 m; TR3105-ød: 0.022 m
ID-Daten - Beschreibung: TR3105-ø22; Hersteller: Stahlwerk Annahütte Max Aicher GmbH Co.KG; Modell: TR 3105=TR3014+TR3013; OmniClass-Nummer: 23.25.10.27.11.21; OmniClass-Titel: Reinforcement Couplers; Typenbild: Rasterbild: TR3105.png; Typenkommentare: TR 3105 - Spannschloss; Typname: TR 3105-ø22; URL: http//:www.annahuette.com
Konstruktion - Endenbearbeitung 1: Endenbearbeitung: Mit Gewinde; Endenbearbeitung 2: Endenbearbeitung: Mit Gewinde; Stabgröße 1: Bewehrungseisen: SAS 670 - ø22; Stabgröße 2: Bewehrungseisen: SAS 670 - ø22
Sonstige - Kategorie: Verbindungsmittel; Familienname: TR3105; Pos_TR3014: 0.08 m; TR3105_Vis: yes; TR3105-G_Vis: yes
Tragwerk - Körper: 1.78 kg; TR3105-G: 1.78 kg
Pset_BuildingElementProxyCommon - Reference: TR3105:TR 3105-ø22
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Pset_QuantityTakeOff - Reference: TR3105:TR 3105-ø22
