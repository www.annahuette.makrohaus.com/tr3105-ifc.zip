Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnr.
Time: 2021-03-16T10:43:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.20.44 - Exporter 21.1.20.44 - Alternativ-UI 21.1.20.44
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 16 10:43:56 2021 * Host: NFR0046 * Database: C:\Users\A_GALL~1\AppData\Local\Temp\4bf9be7f-0f16-4d7c-9241-a983e0998028\71a25a66-2663-4d79-a2a4-bb06e35a13cb\ifc * Database version: 5507 * Database creation date: Tue Mar 16 10:43:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 16 10:43:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 16 10:43:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnr.
LongName: Bauvorhaben; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 48, 7, 58, 799999; RefLongitude: 11, 34, 58, 799999; RefElevation: 0 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de

# IfcBuilding
Text - Bauherr Zeile2: Bauherr (2. Zeile); Bauvorhaben Zeile 2: Bauvorhaben (2. Zeile); Büro Adresse: BiMOTiON GmbH * Burgschmietstraße 40 * 90419 Nürnberg Tel.: 0911/39901-0 * www.bimotion.de * info@bimotion.de
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Geben Sie die Adresse hier ein; Projektausgabedatum: Ausgabedatum; Projektname: Bauvorhaben; Projektnummer: Projektnr.; Projektstatus: Projektstatus
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene UKD, UKD Ebene 0
LongName: UKD Ebene 0; Elevation: -0.2 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene UKD
Grafiken(Type) - Farbe: 33023; Linienmuster: _Strichpunkt - Mittel; Linienstärke: 1; Symbol: Beschriftung Ebene: Unterkante; Symbol bei Ende 1 Standard: yes; Symbol bei Ende 2 Standard: no
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Sonstige - Familie: Ebene: Ebene UKD; Familie und Typ: Ebene: Ebene UKD; Kategorie: Ebenen; Typ: Ebene: Ebene UKD; Typ-ID: Ebene: Ebene UKD
ID-Daten - Gebäudegeschoss: yes; Name: UKD Ebene 0; Tragwerk: no
Pset_AirSideSystemInformation - Name: UKD Ebene 0; sets with these values: 2
Abhängigkeiten - Ansicht: -0.2 m
Abmessungen - Höhe für Berechnung: 0 m

# IfcMechanicalFastener: TR3105:TR 3105-ø63,5, TR3105:TR 3105-ø63,5:1968308: 0
In: UKD Ebene 0
NominalDiameter: 0.328084 m; NominalLength: 1.39436 m
Pset_BuildingElementProxyCommon - Reference: TR3105:TR 3105-ø63,5; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Konstruktion - Verbindungsmittelnummer: 1
Phasen - Phase erstellt: Phase 1
Satz - Menge: 1
Sonstige - Familie: TR3105: TR 3105-ø63,5; Familie und Typ: TR3105: TR 3105-ø63,5; Kategorie: Verbindungsmittel; Typ: TR3105: TR 3105-ø63,5; Typ-ID: TR3105: TR 3105-ø63,5

# IfcBuildingElementProxyType, no part of this type: TR3105:TR 3105-ø63,5
Abmessungen - Außendurchmesser: 0.1 m; Einfassung Stab 1: 0.14 m; Einfassung Stab 2: 0.14 m; Gesamtlänge: 0.425 m; TR3013-L0: 0.035 m; TR3013-Lm: 0.105 m; TR3013-Lw: 0.14 m; TR3013-ød: 0.046 m; TR3013-SW: 0.1 m; TR3014-L: 0.365 m; TR3014-L1: 0.14 m; TR3014-L2: 0.105 m; TR3014-SW: 0.1 m; TR3105-minA: 0.08 m; TR3105-ød: 0.043 m
ID-Daten - Beschreibung: TR3105-ø63,5; Hersteller: Stahlwerk Annahütte Max Aicher GmbH Co.KG; Modell: TR 3105=TR3014+TR3013; OmniClass-Nummer: 23.25.10.27.11.21; OmniClass-Titel: Reinforcement Couplers; Typenbild: Rasterbild: TR3105.png; Typenkommentare: TR 3105 - Spannschloss; Typname: TR 3105-ø63,5; URL: http//:www.annahuette.com
Konstruktion - Endenbearbeitung 1: Endenbearbeitung: Mit Gewinde; Endenbearbeitung 2: Endenbearbeitung: Mit Gewinde; Stabgröße 1: Bewehrungseisen: SAS 670 - ø63,5; Stabgröße 2: Bewehrungseisen: SAS 670 - ø63,5
Sonstige - Kategorie: Verbindungsmittel; Familienname: TR3105; Pos_TR3014: 0.1825 m; TR3105_Vis: yes; TR3105-G_Vis: yes
Tragwerk - Körper: 21.56 kg; TR3105-G: 21.56 kg
Pset_BuildingElementProxyCommon - Reference: TR3105:TR 3105-ø63,5
Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte Max Aicher GmbH Co.KG
Pset_QuantityTakeOff - Reference: TR3105:TR 3105-ø63,5
